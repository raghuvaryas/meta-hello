inherit autotools

SUMMARY = "A simple hello world example" 

SRC_URI = "https://github.com/raghuvaryas/hello-autotools-1.0.git;protocol=https;destsuffix=hello-autotools-1.0;branch=main"

S = "${WORKDIR}/hello-autotools-1.0"
